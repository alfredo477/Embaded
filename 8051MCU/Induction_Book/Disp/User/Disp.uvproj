# Keil uVision project Disp.uvproj, settings and files
target Disp (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Disp +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: STARTUP.A51 main.c
