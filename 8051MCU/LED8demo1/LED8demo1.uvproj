# Keil uVision project LED8demo1.uvproj, settings and files
target LED8demo1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED8demo1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
