# Keil uVision project test_01.uvproj, settings and files
target test_01 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test_01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: STARTUP.A51 main.c
